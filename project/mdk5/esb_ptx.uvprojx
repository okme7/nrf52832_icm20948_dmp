# Keil uVision project esb_ptx.uvprojx, settings and files
target IK-52832DK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x00800000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: nrf52832_qfaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ESB_PRESENT APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\config;..\..\components;..\..\components\boards;..\..\modules\nrfx;..\..\modules\nrfx\hal;..\..\modules\nrfx\mdk;..\..\modules\nrfx\drivers\include;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\components\drivers_nrf\nrf_soc_nosd;..\..\components\libraries\delay;..\..\components\libraries\util;..\..\components\libraries\strerror;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\memobj;..\..\components\libraries\balloc;..\..\components\libraries\ringbuf;..\..\components\libraries\atomic;..\..\components\libraries\uart;..\..\components\libraries\fifo;..\..\components\libraries\atomic_fifo;..\..\components\libraries\sortlist;..\..\components\libraries\timer;..\..\components\libraries\button;..\..\components\proprietary_rf\esb;..\..\external\fprintf;..\..\external\segger_rtt;..\..\app\w25q128;..\..\app\Mahony;..\..\app\util;..\..\app;..\..\components\drivers_nrf\radio_config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x800000 size 0x10000
  link misc: --diag_suppress 6330
  group Application
    ../../app/: main.c ICM_20948.c
    ../config/: sdk_config.h
    ../../app/w25q128/: w25q128.c
  group Board Definition
    ../../components/boards/: boards.c
  group nRF_Drivers
    ../../modules/nrfx/soc/: nrfx_atomic.c
    ../../integration/nrfx/legacy/: nrf_drv_uart.c nrf_drv_clock.c nrf_drv_spi.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../modules/nrfx/drivers/src/: nrfx_uart.c nrfx_uarte.c nrfx_clock.c nrfx_gpiote.c nrfx_spi.c nrfx_spim.c nrfx_timer.c
    ../../components/drivers_nrf/radio_config/: radio_config.c
  group nRF_Libraries
    ../../components/libraries/util/: app_error.c nrf_assert.c app_util_platform.c app_error_handler_keil.c app_error_weak.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../components/libraries/memobj/: nrf_memobj.c
    ../../components/libraries/atomic/: nrf_atomic.c
    ../../components/libraries/balloc/: nrf_balloc.c
    ../../components/libraries/fifo/: app_fifo.c
    ../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../components/libraries/sortlist/: nrf_sortlist.c
    ../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../components/libraries/button/: app_button.c
  group nRF_Properitary_RF
    ../../components/proprietary_rf/esb/: nrf_esb.c
  group nRF_Log
    ../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group DMP
    ../../app/util/: ICM_20948_C.c
software components: CMSIS:CORE 5.3.0, Device:Startup 8.35.0
